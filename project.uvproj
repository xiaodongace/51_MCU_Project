# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\Driver;.\Lib;.\User;.\OS;.\Driver\I2C_OLED;.\Driver\SPI_OLED;.\Driver\Key;.\Driver\Timers;.\Driver\Oscilloscope;.\Driver\NIXIE;.\Driver\Uarts;.\Driver\Buzzer;.\Driver\LED
  group User
    ./User/: main.c
  group App
    ./App/: App_Public.h
    ./App/App_NIXIE/: App_NIXIE_Task.c
    ./App/App_Oscilloscope/: App_Oscilloscope_Task.c
    ./App/App_Buzzer/: App_Buzzer.c
    ./: App_oled.c App.c App.h
  group Driver
    ./Driver/I2C_OLED/: I2C_OLED.c I2C_OLED.h bmp.h oledfont.h
    ./Driver/SPI_OLED/: SPI_OLED.c SPI_OLED.h
    ./Driver/Key/: Key.c
    ./Driver/Timers/: Timers.c
    ./Driver/Oscilloscope/: Oscilloscope.c
    ./Driver/NIXIE/: NIXIE.c NIXIE.h
    ./Driver/RTC_Alarm_Clock/: Alarmclock.c Alarmclock.h
    ./Driver/DHT_1/: DHT1.c DHT1.h
    ./Driver/Uarts/: Uarts.c
    ./Driver/Buzzer/: Buzzer.c
    ./Driver/LED/: LED.c
  group Lib
    ./Lib/: ADC.c ADC_Isr.c Delay.c GPIO.c GPIO_Isr.c I2C.c I2C_Isr.c NVIC.c SPI.c SPI_Isr.c STC8H_PWM.c STC8H_PWM_Isr.c Timer.c Timer_Isr.c UART.c UART_Isr.c
  group OS
    ./OS/: Conf_tny.A51 RTX51TNY.LIB
